# Keil uVision project CM0.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: CM0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS\Include;.\Device\ARM\CMSDK_CM0\Include;..\MDK
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x200000
  group CMSIS
    ./CMSIS/Include/: core_cm0.h core_cmFunc.h core_cmInstr.h
  group Device
    ./Device/ARM/CMSDK_CM0/Source/: CMSDK_driver.c system_CMSDK_CM0.c
    ./Device/ARM/CMSDK_CM0/Source/ARM/: startup_CMSDK_CM0.s
  group User
    ./: main.c systick.c
